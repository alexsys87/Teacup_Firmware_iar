# IAR project Teacup_STM32F401.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401CC ST STM32F401CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F401xC
  ICCARM.CCIncludePath2: ..\; ..\cmsis\core; ..\cmsis\device; ..\core; ..\hal; ..\config; ..\src; ..\motion; ..\display; ..\pff
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Teacup_STM32F401.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\cmsis\linker\stm32f401xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ../app/: mendel.c
  group cmsis
    ../cmsis/: system_stm32f4xx.c
  group config
    ../config/: board.blackpill_stm32f401.h board.blackpill_stm32f411.h config.h config_wrapper.h printer.mendel.h thermistortable.h
  group core
    ../core/: beeper.c babystep.c clock.c filament.c crc.c debug.c flash_files.c heater.c home.c kill.c msg.c pid_autotune.c sd.c sendf.c settings.c status.c thermal_protection.c retract.c host_watch.c power_loss.c fans.c print_stats.c expander.c buttons.c spindle.c tmc.c mpc.c
    ../hal/: step_timers.c
  group display
    ../display/: display.c display_hd44780.c display_ssd1306.c font_6x8.c parallel-4bit.c ui.c
  group hal
    ../hal/: analog.c cpu.c delay.c endstops.c flash_store.c i2c.c pinio.c serial.c servo.c uart.c usb_cdc.c tmc_uart.c spi.c spi_flash.c timer.c watchdog.c
  group motion
    ../motion/: dda.c dda_kinematics.c dda_lookahead.c dda_maths.c dda_queue.c input_shaping.c linear_advance.c
  group pff
    ../pff/: pff.c pff_diskio.c
  group src
    ../src/: bed_leveling.c calibration.c emergency_parser.c gcode_parse.c gcode_process.c gcode_queue.c probe.c temp.c
